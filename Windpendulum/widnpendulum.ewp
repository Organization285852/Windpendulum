# IAR project widnpendulum.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F1611 MSP430F1611
  General.GStackSize2: 400
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: driver; moudle; mpu6050; src
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F1611.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group driver
    driver/: KEY-16.c KEY-16.h lcd12864.c lcd12864.h system.h
  group moudle
    moudle/: motor_control.c motor_control.h PID.c PID.h tarsk.c tarsk.h
  group mpu6050
    mpu6050/: dmp_key.h dmp_map.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h mpu6050.c mpu6050.h mpu_iic.c mpu_iic.h
  group src
    src/: IIC.c IIC.h PWM.c PWM.h timerA.c timerA.h USCI_I2C.h
  group user
    ./: main.c
